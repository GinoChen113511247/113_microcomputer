# Keil uVision project paradigm.uvprojx, settings and files
target stm32f407_FLASH (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flash
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\User_common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user_startup
    ./User_common/: HardwareSystem_Ini.C user_defined.c Serial_Retarget_printf.c callback_example.c
  group Option Bytes
    ./User_common/: STM32F40xxx_41xxx_OPT.s purge_FlashReadProtection_Level_1.c
  group source
    ./Src/: main_FLASH.c main_callback.c
    ./bmp_files/: includeBinary.s
    ./User_common/: GPIO_Ini.c
  group Documentation
    ./Src/: readme.txt
target stm32f407_OPT (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: OPT
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: Board_B
  c include: .\User_common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target RAM (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: RAM
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: Purge_Level_1
  c include: .\User_common
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
target callback (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: Callback
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\User_common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
