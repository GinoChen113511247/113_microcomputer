# Keil uVision project ADC_ELT.uvprojx, settings and files
target RAM_debug (6140000::V6.14::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC_ELT
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\source;.\GLCD;.\User_common
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./User_common/: HardwareSystem_Ini.C user_defined.c GPIO_Ini.c
  group GLCD
    ./GLCD/: stm32f4xx_fsmc.c stm324xg_lcd_ILI9328.c
  group Source
    ./source/: stm32f4_adc_Wizard.c main.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f10x_it.c
    ./User_common/: STM32f4_nvic.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
