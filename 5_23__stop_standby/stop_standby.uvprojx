# Keil uVision project stop_standby.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stop_standby
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\GLCD;.\GLCD\bmp_files;.\SPI_touch;.\User_common;.\PWR_group
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./User_common/: HardwareSystem_Ini.c user_defined.c
  group GLCD
    ./GLCD/: stm32f4xx_fsmc.c stm324xg_lcd_ILI9328.c
  group SPI_touch
    ./SPI_touch/: Driver_SPI.c touch_module.c
  group PWR_group
    ./PWR_group/: main_PWR.c myPower.c myRTC.c NVIC_priorities.c stm32f4_adc_Wizard.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
