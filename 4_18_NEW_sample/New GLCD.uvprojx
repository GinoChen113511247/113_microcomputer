# Keil uVision project New GLCD.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: New GLCD
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\GLCD;.\GLCD\bmp_files
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./source/: main.c HardwareSystem_Ini.C
    ./GLCD/bmp_files/: stlogo.h includeBinary.s
  group GLCD
    ./GLCD/: stm32f4xx_fsmc.c stm324xg_lcd_ILI9341.c
    ./GLCD/tjpgd3/src/: tjpgd.c tjpgd_user.c
    ./GLCD/gif/src/: gif.c gif_user.c
    C:/Users/User/Downloads/New_sample/New_sample/GLCD/: stm324xg_lcd_ILI9328.c
  group callback
    ./GLCD/tjpgd3/src/: callback_EXAMPLE.c
target RAM Debug (6140000::V6.14::ARMCLANG)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: RAM
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\GLCD;.\GLCD\bmp_files
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target callback (6140000::V6.14::ARMCLANG)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: RAM
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Callback_Case
  c include: .\GLCD;.\GLCD\bmp_files;.\GLCD\tjpgd3\src
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
